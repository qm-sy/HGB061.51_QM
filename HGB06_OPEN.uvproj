# Keil uVision project HGB06_OPEN.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: HGB06_QM_test01_20241127.2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc;D:\APP\Keil_v5\C51\INC
  group Source Group 1
    ./: STARTUP.A51
  group Src
    ./Src/: adc.c delay.c eeprom.c gpio.c modbus.c ntc.c pwm.c timer.c uart.c screen.c key.c sync.c
  group User
    ./User/: main.c
  group Inc
    ./Inc/: adc.h delay.h eeprom.h gpio.h modbus.h ntc.h pwm.h timer.h uart.h
